# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F457ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F457ZET7,USE_STDPERIPH_DRIVER,AT_START_F457_V1
  c include: ..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\project\at32f45x_board;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port\arch;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include;..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include\lwip
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c main.c at32_emac.c netconf.c
  group bsp
    ../../../../../project/at32f45x_board/: at32f45x_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f45x_crm.c at32f45x_usart.c at32f45x_emac.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_scfg.c at32f45x_tmr.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group iap
    ../src/: flash.c iap.c tmr.c
  group lwip
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/netif/: ethernet.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/port/: ethernetif.c sys_arch.c
  group http
    ../src/: httpserver.c fsdata.c
  group tftp
    ../src/: tftpserver.c
  group readme
    ../: readme.txt
