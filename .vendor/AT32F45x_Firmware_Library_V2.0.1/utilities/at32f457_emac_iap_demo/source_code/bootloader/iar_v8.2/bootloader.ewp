# IAR project bootloader.ewp, settings and files
configuration bootloader (ARM)
  General.OGChipSelectEditMenu: AT32F457ZET7_v2 ArteryTek AT32F457ZET7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F457ZET7; USE_STDPERIPH_DRIVER; AT_START_F457_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f45x_board; ..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port; ..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\port\arch; ..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include; ..\..\..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include\lwip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: at32f457_emac_bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: AT32F457xE_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32f45x_board/: at32f45x_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f45x.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f45x_crm.c at32f45x_emac.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_scfg.c at32f45x_tmr.c at32f45x_usart.c
  group http
    ../src/: fsdata.c httpserver.c
  group iap
    ../src/: flash.c iap.c tmr.c
  group lwip
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/src/netif/: ethernet.c
    ../../../../../middlewares/3rd_party/lwip_2.1.2/port/: ethernetif.c sys_arch.c
  group readme
    ../: readme.txt
  group tftp
    ../src/: tftpserver.c
  group user
    ../src/: at32_emac.c at32f45x_clock.c at32f45x_int.c main.c netconf.c
