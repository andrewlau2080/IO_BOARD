# Keil uVision project app_led3_toggle.uvprojx, settings and files
target at_start_f457 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F457ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f457_app_led3_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F457ZET7,USE_STDPERIPH_DRIVER,AT_START_F457_V1
  c include: ..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\project\at32f45x_board;..\inc;..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8006000 size 0x7a000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c main.c hid_iap_user.c
  group bsp
    ../../../../../project/at32f45x_board/: at32f45x_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f45x_acc.c at32f45x_crc.c at32f45x_crm.c at32f45x_usart.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group usbd_driver
    ../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
target at_start_f456 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: as above
  output: f456_app_led3_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F456ZET7,USE_STDPERIPH_DRIVER,AT_START_F456_V1
  c include: as above
  memory RVCT4: ROM 0x8006000 size 0x7a000
  memory RVCT9: RAM 0x20000000 size 0x24000
target at_start_f455 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F455ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: as above
  output: f455_app_led3_toggle +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F455ZET7,USE_STDPERIPH_DRIVER,AT_START_F455_V1
  c include: as above
  memory RVCT4: ROM 0x8006000 size 0x7a000
  memory RVCT9: RAM 0x20000000 size 0x24000
