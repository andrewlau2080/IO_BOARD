# IAR project bootloader.ewp, settings and files
configuration at_start_f457 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F457ZET7_v2 ArteryTek AT32F457ZET7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F457ZET7; USE_STDPERIPH_DRIVER; AT_START_F457_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f45x_board; ..\..\..\..\..\middlewares\usbd_class\hid_iap; ..\..\..\..\..\middlewares\usb_drivers\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: AT32F457xE_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f456 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F456ZET7_v2 ArteryTek AT32F456ZET7
  ICCARM.CCDefines: AT32F456ZET7; USE_STDPERIPH_DRIVER; AT_START_F456_V1
  ILINK.IlinkIcfFile: AT32F456xE_bootloader.icf
configuration at_start_f455 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F455ZET7_v2 ArteryTek AT32F455ZET7
  ICCARM.CCDefines: AT32F455ZET7; USE_STDPERIPH_DRIVER; AT_START_F455_V1
  ILINK.IlinkIcfFile: AT32F455xE_bootloader.icf
  group bsp
    ../../../../../project/at32f45x_board/: at32f45x_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f45x.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f45x_acc.c at32f45x_crc.c at32f45x_crm.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_usart.c at32f45x_usb.c
  group readme
    ../: readme.txt
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group usbd_drivers
    ../../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c hid_iap_user.c main.c
