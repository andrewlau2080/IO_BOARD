<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project_l1.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>project_l1</project>
                <configuration>at_start_f455</configuration>
            </member>
            <member>
                <project>project_l1</project>
                <configuration>at_start_f456</configuration>
            </member>
            <member>
                <project>project_l1</project>
                <configuration>at_start_f457</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
