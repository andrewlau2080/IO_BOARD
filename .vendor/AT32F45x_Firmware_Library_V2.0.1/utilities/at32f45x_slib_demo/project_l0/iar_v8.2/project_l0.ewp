# IAR project project_l0.ewp, settings and files
configuration at_start_f455 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F455ZET7_v2 ArteryTek AT32F455ZET7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F455ZET7; USE_STDPERIPH_DRIVER; AT_START_F455_V1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\inc; ..\..\..\..\project\at32f45x_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_l0.hex
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: project_l0.out
  ILINK.IlinkIcfFile: AT32F455xE_slib.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_f456 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F456ZET7_v2 ArteryTek - AT32F456ZET7
  ICCARM.CCDefines: AT32F456ZET7; USE_STDPERIPH_DRIVER; AT_START_F456_V1; ARM_MATH_CM4
  ILINK.IlinkIcfFile: AT32F456xE_slib.icf
configuration at_start_f457 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F457ZET7_v2 ArteryTek AT32F457ZET7
  ICCARM.CCDefines: AT32F457ZET7; USE_STDPERIPH_DRIVER; AT_START_F457_V1; ARM_MATH_CM4
  ILINK.IlinkIcfFile: AT32F457xE_slib.icf
  group bsp
    ../../../../project/at32f45x_board/: at32f45x_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f45x.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group firmware
    ../../../../libraries/drivers/src/: at32f45x_crm.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c at32f45x_clock.c at32f45x_int.c main.c math_helper.c
