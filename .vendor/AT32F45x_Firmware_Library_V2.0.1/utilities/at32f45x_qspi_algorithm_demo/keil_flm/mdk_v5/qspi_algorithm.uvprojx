# Keil uVision project qspi_algorithm.uvprojx, settings and files
target qspi_algorithm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F457ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f45x_qspi_algorithm +hex
  AfterMake: cmd.exe /C copy !L .\@L.FLM
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F457ZET7
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../src/: FlashPrg.c qspi_gpio_select.c
  group Device Description
    ../src/: FlashDev.c
  group readme
    ../: readme.txt
