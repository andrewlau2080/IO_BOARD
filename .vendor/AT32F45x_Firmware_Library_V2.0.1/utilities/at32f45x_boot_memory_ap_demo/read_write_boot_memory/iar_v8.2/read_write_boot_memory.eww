<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\read_write_boot_memory.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>read_write_boot_memory</project>
                <configuration>at_start_f455</configuration>
            </member>
            <member>
                <project>read_write_boot_memory</project>
                <configuration>at_start_f456</configuration>
            </member>
            <member>
                <project>read_write_boot_memory</project>
                <configuration>at_start_f457</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
