# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F456ZET7,USE_STDPERIPH_DRIVER,AT_START_F456_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f45x_board
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c main.c
  group bsp
    ../../../at32f45x_board/: at32f45x_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f45x_acc.c at32f45x_adc.c at32f45x_aes.c at32f45x_can.c at32f45x_crc.c at32f45x_crm.c at32f45x_dac.c at32f45x_debug.c at32f45x_dma.c at32f45x_emac.c at32f45x_ertc.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_i2c.c at32f45x_misc.c at32f45x_pwc.c at32f45x_qspi.c at32f45x_scfg.c at32f45x_sdio.c at32f45x_spi.c at32f45x_tmr.c at32f45x_trng.c at32f45x_usart.c at32f45x_usb.c at32f45x_wdt.c at32f45x_wwdt.c at32f45x_xmc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
  group readme
    ../: readme.txt
