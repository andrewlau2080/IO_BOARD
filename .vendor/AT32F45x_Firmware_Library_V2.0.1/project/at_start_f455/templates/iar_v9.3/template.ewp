# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: AT32F455ZET7_v2 ArteryTek AT32F455ZET7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F455ZET7; USE_STDPERIPH_DRIVER; AT_START_F455_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f45x_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../at32f45x_board/: at32f45x_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f45x.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f45x.c
  group firmware
    ../../../../libraries/drivers/src/: at32f45x_acc.c at32f45x_adc.c at32f45x_aes.c at32f45x_can.c at32f45x_crc.c at32f45x_crm.c at32f45x_dac.c at32f45x_debug.c at32f45x_dma.c at32f45x_emac.c at32f45x_ertc.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_i2c.c at32f45x_misc.c at32f45x_pwc.c at32f45x_qspi.c at32f45x_scfg.c at32f45x_sdio.c at32f45x_spi.c at32f45x_tmr.c at32f45x_trng.c at32f45x_usart.c at32f45x_usb.c at32f45x_wdt.c at32f45x_wwdt.c at32f45x_xmc.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f45x_clock.c at32f45x_int.c main.c
