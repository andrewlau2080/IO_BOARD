# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104E STC15F100E Series
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: main +hex
  c flags: Optimize=9 SizeSpeed=1
  group main
    ./mian/: main.c
  group hader
    ./hadder/: STC15W.h tm1637.h
  group tm1637
    ./tm1637/: tm1637.c
